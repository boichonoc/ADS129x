# IAR project ADS129x_3V3_STM32L151.ewp, settings and files
configuration ADS129x_3V3_STM32L151 (ARM, debug)
  General.OGChipSelectEditMenu: STM32L151CC ST STM32L151CC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L151xC
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32L1xx_HAL_Driver/Inc; ../Drivers/STM32L1xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32L1xx/Include; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: ADS129x_3V3_STM32L151.out
  ILINK.IlinkIcfFile: stm32l151xc_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../Inc/: ADS1294.h
    ../Src/: ADS1294_Init.c ADS1294_ReadData_FormatAndRecive.c ADS1294_RW_SendComand.c ADS1294_SetConfigurations.c
  group Application/EWARM
    ./: startup_stm32l151xc.s
  group Application/User
    ../Src/: main.c stm32l1xx_hal_msp.c stm32l1xx_it.c
  group Drivers/CMSIS
    ../Src/: system_stm32l1xx.c
  group Drivers/STM32L1xx_HAL_Driver
    ../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal.c stm32l1xx_hal_cortex.c stm32l1xx_hal_dma.c stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_gpio.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_spi.c stm32l1xx_hal_spi_ex.c stm32l1xx_hal_tim.c stm32l1xx_hal_tim_ex.c stm32l1xx_hal_uart.c stm32l1xx_hal_dac.c stm32l1xx_hal_dac_ex.c
